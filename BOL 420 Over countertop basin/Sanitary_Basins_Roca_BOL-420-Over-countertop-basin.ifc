Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Basins_Roca_BOL-420-Over-countertop-basin.ifc
Time: 2019-10-10T08:41:40
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: BOL 420 Over countertop basin
ePset_BIMobjectScript - COLOR: WHITE; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): BOL 420 Over countertop basin; SKU (BO_prodsku): 327876xx0; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): Bol; ProductGroup (BO_prodgroup): BASINS; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; PublishDate (BO_publisdat): 10/21/2015; EditionNumber (BO_edinum): 1; Width (BO_width): 420; Height (BO_height): 230; Depth (BO_depth): 420; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/327876xx0; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/327876xx0; ProductUrl (BO_producturl): http://www.roca.com/catalogue/products/basins/countertop-basins-0102/countertop-vitreous-china-basin-327876..0; TechnicalDescription (BO_techcert): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject={1C12CD6D-C1D1-4F93-ACE7-531112211278}; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Vitreous china; MaterialSecondary (BO_secmat): Vitreous china; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Basins; BimObjectCategoryCode (BO_bocat_code): sanitary-basins; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L7212; Uniclass14Description (BO_uniclass_1_4_desc): Washbasins; Uniclass20Code (BO_uniclass_2_0_code): SS-35-65-70-94; Uniclass20Description (BO_uniclass_2_0_desc): Wash Basin Systems; NBSReference (BO_nbs_ref): 35-65-70-94; NBSReferenceDescription (BO_nbs_desc): Wash Basin Systems; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
